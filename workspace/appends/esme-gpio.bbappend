inherit externalsrc
EXTERNALSRC = "/home/jourdes/w/src/gpio-toggle"
EXTERNALSRC_BUILD = "/home/jourdes/w/src/gpio-toggle"

# initial_rev .: 6de96aa5be2c23f536cacd7d542735a541177837
